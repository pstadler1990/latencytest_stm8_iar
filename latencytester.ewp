# IAR project latencytester.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105; USE_STDPERIPH_DRIVER; USE_SID
  ICCSTM8.CCIncludePath2: latencytest_stm8_iar-master\Libraries; latencytest_stm8_iar-master\Libraries\STM8S_StdPeriph_Driver; latencytest_stm8_iar-master\Libraries\STM8S_StdPeriph_Driver\inc; latencytest_stm8_iar-master
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    latencytest_stm8_iar-master/: communication.c communication.h configuration.h main.c main.h measurement.c measurement.h stm8s_conf.h stm8s_it.c stm8s_it.h timing.c timing.h
  group STM8_Library
    latencytest_stm8_iar-master/Libraries/STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_adc2.c stm8s_awu.c stm8s_beep.c stm8s_can.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_tim5.c stm8s_tim6.c stm8s_uart1.c stm8s_uart2.c stm8s_uart3.c stm8s_uart4.c stm8s_wwdg.c
